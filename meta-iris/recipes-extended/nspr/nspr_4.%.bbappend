
# Remove perl dependency
RDEPENDS:${PN}-dev:remove = "perl"
