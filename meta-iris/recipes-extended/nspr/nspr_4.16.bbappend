
# Remove perl dependency
RDEPENDS_${PN}-dev_remove = "perl"
