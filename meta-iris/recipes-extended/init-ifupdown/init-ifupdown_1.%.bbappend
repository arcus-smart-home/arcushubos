FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

# Use our interfaces file
SRC_URI += "file://interfaces \
	    "


